PACKAGECONFIG[ppp] = "-Dppp=true -Dpppd_plugin_dir='${libdir}/pppd/2.4.9' -Dpppd=${sbindir}/pppd,-Dppp=false,ppp,ppp"
