SUMMARY = "Generate release bundle"

inherit release-bundle-generation
