FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-configure.ac-Link-with-latomic-only-if-no-atomic-bui.patch"
