# Disabled by default to avoid conflicts with NM/systemd
SYSTEMD_AUTO_ENABLE:oel = "disable"
